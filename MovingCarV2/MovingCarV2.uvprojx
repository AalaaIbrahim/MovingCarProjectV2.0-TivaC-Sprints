# Keil uVision project MovingCarV2.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MovingCarV2 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: .\APP;.\HAL\btn;.\HAL\led;.\HAL\pwm;.\LIB;.\MCAL\gpio;.\MCAL\gpt;.\HAL\delay;.\HAL\dcm
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MAIN
    ./: main.c
  group LIB
    ./LIB/: bit_math.h std.h
  group MCAL
    ./MCAL/gpio/: gpio_interface.h gpio_private.h gpio_program.c
    ./MCAL/gpt/: gpt_interface.h gpt_linking_cfg.c gpt_linking_cfg.h gpt_private.h gpt_program.c
  group HAL
    ./HAL/btn/: btn_interface.h btn_program.c
    ./HAL/led/: led_interface.h led_program.c
    ./HAL/pwm/: pwm_interface.h pwm_linking_cfg.c pwm_linking_cfg.h pwm_program.c
    ./HAL/delay/: delay_interface.h delay_program.c
    ./HAL/dcm/: dcm_cfg.c dcm_program.c
  group APP
    ./APP/: app_interface.h app_private.h app_program.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
